# IAR project sa_check.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\src\config; ..\src\os\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: sa_check.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../src/os/: cli.cpp clock.cpp coroutine.cpp critical.cpp fsm.cpp kernel.cpp list.cpp memory.cpp prioQueue.cpp queue.cpp task.cpp timer.cpp util.cpp
    ../src/os/include/: cli.hpp clock.hpp coroutine.hpp critical.hpp fsm.hpp helper.hpp kernel.hpp list.hpp memory.hpp prioqueue.hpp queue.hpp task.hpp timer.hpp types.hpp util.hpp
    ./: main.cpp
